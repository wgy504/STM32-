# Keil uVision project STM32-zhinenggui.uvproj, settings and files
target STM32-FD-LED-ucos (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32-FD-ucos +hex
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210B_EVAL
  c include: ..\APP;..\BSP;..\FWLib\inc;..\Startup;..\uCOS-II\Source;..\uCOS-II\uC-CPU;..\uCOS-II\uC-LIB;..\uCOS-II\Ports;..\CM3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Startup/: stm32f10x_startup.s
  group APP
    ./: app.c stm32f10x_it.c globals.c
  group BSP
    ../BSP/: bsp.c
  group FWLib
    ../FWlib/SRC/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_tim.c
  group uC-OS-II/Port
    ../uCOS-II/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uC-OS-II/CPU
    ../uCOS-II/uC-CPU/: cpu_a.asm
  group uC-OS-II/Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c os_mutex.c
  group Documentation
    ./: readme.txt
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
  group LCD Driver
    ../LCD_Driver/: LCD_Dis.c LCD_Config.h LCD_Dis.h
  group SPI_Flash
    ./: SPI_Flash.c SPI_Flash.h
  group PCA9555
    ./: I2C.c I2C.h
  group Fifo4Serial
    ./: Fifo4Serial.c
